Commit message: add adaptive controller config + exciting faster offline trajectories

File: models/urdf/gen3_2f85_dumbbell_8lb.urdf (robot description, URDF)
Before this commit: robot gen3_2f85_dumbbell_6lb, 22 links, 21 joints
Links:
- link object_link: mass 3.17514659 -> 3.62873896
